# Keil uVision project 00ctl_board.uvprojx, settings and files
target 00ctl_board (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: 00ctl_board +hex
  AfterMake: fromelf --bin --output C:\software\o2floPro_valve_driver\O2Flo_Valve_driver\00ctl_board\MDK-ARM\00ctl_board\00ctl_board.bin C:\software\o2floPro_valve_driver\O2Flo_Valve_driver\00ctl_board\MDK-ARM\00ctl_board\00ctl_board.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x8
  c include: ../Inc;                                                                                                    ../Drivers/STM32F0xx_HAL_Driver/Inc;                                                                                                    ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;                                                                                                    ../Middlewares/Third_Party/FreeRTOS/Source/include;                                                                                                    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                                                                                                    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0;                                                                                                    ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;                                                                                                    ../Drivers/CMSIS/Include;                                                                                                    ../source/app;                                                                                                    ../source/module;                                                                                                    ../source/bsp;                                                                                                    ../source/system/pid;                                                                                                    ../source/system/cmd;                                                                                                    ../source/system/fifo;                                                                                                    ../source/system/common
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xd000
  memory RVCT9: RAM 0x200000c0 size 0x1f40
  group Application/MDK-ARM
    ./: startup_stm32f030x8.s
  group Application/User
    ../Src/: main.c freertos.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
  group APP
    ../source/APP/: app.c
  group Module
    ../source/Module/: comm_module.c flow_module.c interface_module.c sampling_module.c comm_task.c comm_def.h
  group BSP
    ../source/BSP/: bsp_spi_flash.c sf05.c i2c_hal.c
  group System
    ../source/System/cmd/: CMD_Receive.c
    ../source/System/common/: common.c
    ../source/System/fifo/: fifo.c
    ../source/System/pid/: pid.c
software components: CMSIS:CORE 4.3.0
